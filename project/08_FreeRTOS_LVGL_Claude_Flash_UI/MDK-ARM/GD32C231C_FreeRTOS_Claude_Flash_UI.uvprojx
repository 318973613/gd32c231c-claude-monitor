# Keil uVision project GD32C231C_FreeRTOS_Claude_Flash_UI.uvprojx, settings and files
target GD32C231C_FreeRTOS_Claude_Flash_UI (6220000::V6.22::ARMCLANG)
  device: GD32C231C8 GigaDevice
  pack: GigaDevice.GD32C2x1_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0003000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Claude_Flash_UI +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\GD32C2x1_Firmware_Library\CMSIS\GD\GD32C2x1\Include;..\..\GD32C2x1_Firmware_Library\GD32C2x1_standard_peripheral\Include;..\;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM23_NTZ\non_secure;..\BSP_LCD;..\LVGL;..\LVGL\src;..\BSP_DHT11;..\BSP_SPI_FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application
    ../: main.c gd32c2x1_it.c app_led_effect.c app_serial_clock.c app_ai_link.c app_dashboard.c app_flash_assets.c
  group CMSIS
    ../../GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/: system_gd32c2x1.c
  group GD32C2x1_Peripherals
    ../../GD32C2x1_Firmware_Library/GD32C2x1_standard_peripheral/Source/: gd32c2x1_gpio.c gd32c2x1_rcu.c gd32c2x1_spi.c gd32c2x1_misc.c gd32c2x1_syscfg.c gd32c2x1_usart.c
  group FreeRTOS
    ../FreeRTOS/: tasks.c queue.c list.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
  group BSP_LCD
    ../BSP_LCD/: lcd_driver.c
  group BSP_DHT11
    ../BSP_DHT11/: dht11.c
  group BSP_SPI_FLASH
    ../BSP_SPI_FLASH/: gd25qxx.c
  group LVGL
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_unscii_8.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/widgets/: lv_label.c
  group Startup
    ../../GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/ARM/: startup_gd32c2x1.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
